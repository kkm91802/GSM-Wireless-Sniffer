options:
  parameters:
    author: kamal&sayak
    generate_options: qt_gui
    id: DS_LAB_Research_Paper
    output_language: python
    title: WIRELESS_SNIFFER
  states: {}

blocks:
- name: Length_Mov_AVG
  id: variable
  parameters:
    value: 2u
  states: {}
- name: Length_Mov_AVG_INV
  id: variable
  parameters:
    value: 2u
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: meeting_levelGauge
  id: variable_qtgui_label
  parameters:
    label: Signal Level dBm
    type: int
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: meeting_level
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '500000'
    max_iter: '4000'
    scale: 2e6
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 100e3
    type: complex
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 2.75e6
    decim: '1'
    gain: '1'
    samp_rate: '10000000'
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3.25e6
    decim: '1'
    gain: '1'
    samp_rate: 10e6
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_throttle2_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
